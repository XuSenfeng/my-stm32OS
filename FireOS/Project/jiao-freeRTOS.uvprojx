# Keil uVision project jiao-freeRTOS.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: jiaofreeRTOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\freertos\include;..\freertos\portable\RVDS\ARM_CM3;..\USER;..\freertos;..\freertos\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group user
    ../USER/: main.c
  group FreeRTOS/Ports
    ../freertos/portable/RVDS/ARM_CM3/: port.c
  group FreeRTOS/Source
    ../freertos/: list.c task.c
    ../freertos/include/: FreeRTOSConfig.h list.h portmacro.h FreeRTOS.h task.h
  group Document
    ../Doc/: Direction.md
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.1
